# Keil uVision project LoadApp.uvprojx, settings and files
target LoadApp (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoadApp +hex
  AfterMake: fromelf.exe  --bin -o .\Objects\LoadApp.bin .\Objects\LoadApp.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\NET\device\inc;.\NET\EDP;.\NET\onenet\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8007ff8 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_i2c.c
  group hardware
    ./hardware/src/: delay.c usart.c beep.c led.c key.c i2c_ee.c
  group user
    ./user/: main.c version.c
  group OneNET
    ./NET/onenet/src/: onenet.c
  group net_protocol
    ./NET/EDP/: EdpKit.c
  group net_device
    ./NET/device/src/: esp8266.c
